# IAR project beacon.ewp, settings and files
configuration nrf52832_xxaa (ARM)
  General.OGChipSelectEditMenu: nrf52832_xxaa nRF52832_xxAA
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: APP_TIMER_V2; APP_TIMER_V2_RTC1_ENABLED; BOARD_PCA10040; CONFIG_GPIO_AS_PINRESET; FLOAT_ABI_HARD; NRF52; NRF52832_XXAA; NRF52_PAN_74; NRF_SD_BLE_API_VERSION=7; S132; SOFTDEVICE_PRESENT
  ICCARM.IExtraOptions: --diag_suppress Pe111
  ICCARM.CCIncludePath2: ..\..\USER; ..\..\SDK\components; ..\..\SDK\components\ble\ble_advertising; ..\..\SDK\components\ble\ble_dtm; ..\..\SDK\components\ble\ble_racp; ..\..\SDK\components\ble\ble_services\ble_ancs_c; ..\..\SDK\components\ble\ble_services\ble_ans_c; ..\..\SDK\components\ble\ble_services\ble_bas; ..\..\SDK\components\ble\ble_services\ble_bas_c; ..\..\SDK\components\ble\ble_services\ble_cscs; ..\..\SDK\components\ble\ble_services\ble_cts_c; ..\..\SDK\components\ble\ble_services\ble_dfu; ..\..\SDK\components\ble\ble_services\ble_dis; ..\..\SDK\components\ble\ble_services\ble_gls; ..\..\SDK\components\ble\ble_services\ble_hids; ..\..\SDK\components\ble\ble_services\ble_hrs; ..\..\SDK\components\ble\ble_services\ble_hrs_c; ..\..\SDK\components\ble\ble_services\ble_hts; ..\..\SDK\components\ble\ble_services\ble_ias; ..\..\SDK\components\ble\ble_services\ble_ias_c; ..\..\SDK\components\ble\ble_services\ble_lbs; ..\..\SDK\components\ble\ble_services\ble_lbs_c; ..\..\SDK\components\ble\ble_services\ble_lls; ..\..\SDK\components\ble\ble_services\ble_nus; ..\..\SDK\components\ble\ble_services\ble_nus_c; ..\..\SDK\components\ble\ble_services\ble_rscs; ..\..\SDK\components\ble\ble_services\ble_rscs_c; ..\..\SDK\components\ble\ble_services\ble_tps; ..\..\SDK\components\ble\common; ..\..\SDK\components\ble\nrf_ble_gatt; ..\..\SDK\components\ble\nrf_ble_qwr; ..\..\SDK\components\ble\peer_manager; ..\..\SDK\components\boards; ..\..\SDK\components\libraries\atomic; ..\..\SDK\components\libraries\atomic_fifo; ..\..\SDK\components\libraries\atomic_flags; ..\..\SDK\components\libraries\balloc; ..\..\SDK\components\libraries\bootloader\ble_dfu; ..\..\SDK\components\libraries\button; ..\..\SDK\components\libraries\cli; ..\..\SDK\components\libraries\crc16; ..\..\SDK\components\libraries\crc32; ..\..\SDK\components\libraries\crypto; ..\..\SDK\components\libraries\csense; ..\..\SDK\components\libraries\csense_drv; ..\..\SDK\components\libraries\delay; ..\..\SDK\components\libraries\ecc; ..\..\SDK\components\libraries\experimental_section_vars; ..\..\SDK\components\libraries\experimental_task_manager; ..\..\SDK\components\libraries\fds; ..\..\SDK\components\libraries\fstorage; ..\..\SDK\components\libraries\gfx; ..\..\SDK\components\libraries\gpiote; ..\..\SDK\components\libraries\hardfault; ..\..\SDK\components\libraries\hci; ..\..\SDK\components\libraries\led_softblink; ..\..\SDK\components\libraries\log; ..\..\SDK\components\libraries\log\src; ..\..\SDK\components\libraries\low_power_pwm; ..\..\SDK\components\libraries\mem_manager; ..\..\SDK\components\libraries\memobj; ..\..\SDK\components\libraries\mpu; ..\..\SDK\components\libraries\mutex; ..\..\SDK\components\libraries\pwm; ..\..\SDK\components\libraries\pwr_mgmt; ..\..\SDK\components\libraries\queue; ..\..\SDK\components\libraries\ringbuf; ..\..\SDK\components\libraries\scheduler; ..\..\SDK\components\libraries\sdcard; ..\..\SDK\components\libraries\slip; ..\..\SDK\components\libraries\sortlist; ..\..\SDK\components\libraries\spi_mngr; ..\..\SDK\components\libraries\stack_guard; ..\..\SDK\components\libraries\strerror; ..\..\SDK\components\libraries\svc; ..\..\SDK\components\libraries\timer; ..\..\SDK\components\libraries\twi_mngr; ..\..\SDK\components\libraries\twi_sensor; ..\..\SDK\components\libraries\usbd; ..\..\SDK\components\libraries\usbd\class\audio; ..\..\SDK\components\libraries\usbd\class\cdc; ..\..\SDK\components\libraries\usbd\class\cdc\acm; ..\..\SDK\components\libraries\usbd\class\hid; ..\..\SDK\components\libraries\usbd\class\hid\generic; ..\..\SDK\components\libraries\usbd\class\hid\kbd; ..\..\SDK\components\libraries\usbd\class\hid\mouse; ..\..\SDK\components\libraries\usbd\class\msc; ..\..\SDK\components\libraries\util; ..\..\SDK\components\nfc\ndef\conn_hand_parser; ..\..\SDK\components\nfc\ndef\conn_hand_parser\ac_rec_parser; ..\..\SDK\components\nfc\ndef\conn_hand_parser\ble_oob_advdata_parser; ..\..\SDK\components\nfc\ndef\conn_hand_parser\le_oob_rec_parser; ..\..\SDK\components\nfc\ndef\connection_handover\ac_rec; ..\..\SDK\components\nfc\ndef\connection_handover\ble_oob_advdata; ..\..\SDK\components\nfc\ndef\connection_handover\ble_pair_lib; ..\..\SDK\components\nfc\ndef\connection_handover\ble_pair_msg; ..\..\SDK\components\nfc\ndef\connection_handover\common; ..\..\SDK\components\nfc\ndef\connection_handover\ep_oob_rec; ..\..\SDK\components\nfc\ndef\connection_handover\hs_rec; ..\..\SDK\components\nfc\ndef\connection_handover\le_oob_rec; ..\..\SDK\components\nfc\ndef\generic\message; ..\..\SDK\components\nfc\ndef\generic\record; ..\..\SDK\components\nfc\ndef\launchapp; ..\..\SDK\components\nfc\ndef\parser\message; ..\..\SDK\components\nfc\ndef\parser\record; ..\..\SDK\components\nfc\ndef\text; ..\..\SDK\components\nfc\ndef\uri; ..\..\SDK\components\nfc\platform; ..\..\SDK\components\nfc\t2t_lib; ..\..\SDK\components\nfc\t2t_parser; ..\..\SDK\components\nfc\t4t_lib; ..\..\SDK\components\nfc\t4t_parser\apdu; ..\..\SDK\components\nfc\t4t_parser\cc_file; ..\..\SDK\components\nfc\t4t_parser\hl_detection_procedure; ..\..\SDK\components\nfc\t4t_parser\tlv; ..\..\SDK\components\softdevice\common; ..\..\SDK\components\softdevice\s132\headers; ..\..\SDK\components\softdevice\s132\headers\nrf52; ..\..\SDK\components\toolchain\cmsis\include; ..\..\SDK\external\fprintf; ..\..\SDK\external\segger_rtt; ..\..\SDK\external\utf_converter; ..\..\SDK\integration\nrfx; ..\..\SDK\integration\nrfx\legacy; ..\..\SDK\modules\nrfx; ..\..\SDK\modules\nrfx\drivers\include; ..\..\SDK\modules\nrfx\hal; ..\..\SDK\modules\nrfx\mdk
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: ble_app_multiperipheral_pca10040_s132.hex
  ILINK.IlinkOutputFile: ble_app_multiperipheral_pca10040_s132.out
  ILINK.IlinkIcfFile: beacon.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application
    ../../USER/: main.c sdk_config.h
  group Board Definition
    ../../SDK/components/boards/: boards.c
  group None
    ../../SDK/modules/nrfx/mdk/: iar_startup_nrf52.s system_nrf52.c
  group nRF_BLE
    ../../SDK/components/ble/common/: ble_advdata.c ble_conn_params.c ble_conn_state.c ble_srv_common.c
    ../../SDK/components/ble/nrf_ble_gatt/: nrf_ble_gatt.c
    ../../SDK/components/ble/nrf_ble_qwr/: nrf_ble_qwr.c
  group nRF_BLE_Services
    ../../SDK/components/ble/ble_services/ble_lbs/: ble_lbs.c
  group nRF_Drivers
    ../../SDK/integration/nrfx/legacy/: nrf_drv_clock.c nrf_drv_uart.c
    ../../SDK/modules/nrfx/soc/: nrfx_atomic.c
    ../../SDK/modules/nrfx/drivers/src/: nrfx_clock.c nrfx_gpiote.c nrfx_uart.c nrfx_uarte.c
    ../../SDK/modules/nrfx/drivers/src/prs/: nrfx_prs.c
  group nRF_Libraries
    ../../SDK/components/libraries/button/: app_button.c
    ../../SDK/components/libraries/util/: app_error.c app_error_handler_iar.c app_error_weak.c app_util_platform.c nrf_assert.c
    ../../SDK/components/libraries/scheduler/: app_scheduler.c
    ../../SDK/components/libraries/timer/: app_timer2.c drv_rtc.c
    ../../SDK/components/libraries/hardfault/: hardfault_implementation.c
    ../../SDK/components/libraries/atomic_fifo/: nrf_atfifo.c
    ../../SDK/components/libraries/atomic_flags/: nrf_atflags.c
    ../../SDK/components/libraries/atomic/: nrf_atomic.c
    ../../SDK/components/libraries/balloc/: nrf_balloc.c
    ../../SDK/external/fprintf/: nrf_fprintf.c nrf_fprintf_format.c
    ../../SDK/components/libraries/memobj/: nrf_memobj.c
    ../../SDK/components/libraries/pwr_mgmt/: nrf_pwr_mgmt.c
    ../../SDK/components/libraries/ringbuf/: nrf_ringbuf.c
    ../../SDK/components/libraries/experimental_section_vars/: nrf_section_iter.c
    ../../SDK/components/libraries/sortlist/: nrf_sortlist.c
    ../../SDK/components/libraries/strerror/: nrf_strerror.c
  group nRF_Log
    ../../SDK/components/libraries/log/src/: nrf_log_backend_rtt.c nrf_log_backend_serial.c nrf_log_backend_uart.c nrf_log_default_backends.c nrf_log_frontend.c nrf_log_str_formatter.c
  group nRF_Segger_RTT
    ../../SDK/external/segger_rtt/: SEGGER_RTT.c SEGGER_RTT_printf.c SEGGER_RTT_Syscalls_IAR.c
  group nRF_SoftDevice
    ../../SDK/components/softdevice/common/: nrf_sdh.c nrf_sdh_ble.c nrf_sdh_soc.c
  group UTF8/UTF16 converter
    ../../SDK/external/utf_converter/: utf.c
